# IAR project Arton_DL1R.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430G2433 MSP430G2433
  General.GStackSize2: 100
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\; .\
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  group (top)
    ../: delay.c delay.h flash.c flash.h hardware.c hardware.h main.c main.h soft_uart.c soft_uart.h type.h VersionHistory.txt
